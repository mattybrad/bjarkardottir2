File: pcb/body2/power.kicad_sch (KiCad schematic)
At the start: 17 parts, among them U5 AP7313-18SAG, U9 TPS54331DR

Commit message: kicad 9
Parts:
- renumbered U5 to U10
